options:
  parameters:
    generate_options: qt_gui
    id: rfnoc_PulseShapingFilter
    output_language: python
    title: 'RFNoC: PulseShapingFilter Example'
  states: {}

blocks:
- name: ettus_rfnoc_graph
  id: ettus_rfnoc_graph
  parameters:
    clock_source_0: ''
    clock_source_1: ''
    clock_source_2: ''
    clock_source_3: ''
    clock_source_4: ''
    clock_source_5: ''
    clock_source_6: ''
    clock_source_7: ''
    dev_addr: ''
    dev_args: type=x300
    num_mboards: '1'
    time_source_0: ''
    time_source_1: ''
    time_source_2: ''
    time_source_3: ''
    time_source_4: ''
    time_source_5: ''
    time_source_6: ''
    time_source_7: ''
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    label: Sampling Rate (Hz)
    type: real
    value: 1e6
  states: {}
- name: variable_qtgui_range_amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    min_len: '1000'
    orient: Qt.Horizontal
    start: '0'
    step: 1/1000
    stop: '1'
    value: '1'
  states: {}
- name: variable_qtgui_range_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    min_len: '1000'
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/1000
    stop: samp_rate/2
    value: samp_rate/10
  states: {}
- name: variable_qtgui_range_user_reg
  id: variable_qtgui_range
  parameters:
    label: User Reg
    min_len: '1000'
    orient: Qt.Horizontal
    rangeType: int
    start: '-2**15-1'
    step: '1'
    stop: 2**15-1
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: variable_qtgui_range_amplitude
    freq: variable_qtgui_range_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ettus_rfnoc_rx_streamer_0
  id: ettus_rfnoc_rx_streamer
  parameters:
    args: ''
    num_chans: '1'
    otw: sc16
    output_type: fc32
    vlen: '1'
  states: {}
- name: ettus_rfnoc_tx_streamer_0
  id: ettus_rfnoc_tx_streamer
  parameters:
    args: ''
    input_type: fc32
    num_chans: '1'
    otw: sc16
    vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: tutorial_PulseShapingFilter_0
  id: tutorial_PulseShapingFilter
  parameters:
    block_args: ''
    device_select: '-1'
    instance_select: '-1'
    user_reg: variable_qtgui_range_user_reg
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', ettus_rfnoc_tx_streamer_0, '0']
- [ettus_rfnoc_rx_streamer_0, '0', qtgui_time_sink_x_0, '0']
- [ettus_rfnoc_tx_streamer_0, '0', tutorial_PulseShapingFilter_0, '0']
- [tutorial_PulseShapingFilter_0, '0', ettus_rfnoc_rx_streamer_0, '0']

metadata:
  file_format: 1
