options:
  parameters:
    generate_options: qt_gui
    id: rfnoc_conv32Bto2B
    output_language: python
    title: 'RFNoC: conv32Bto2B Example'
  states: {}

blocks:
- name: ettus_rfnoc_graph
  id: ettus_rfnoc_graph
  parameters:
    clock_source_0: ''
    clock_source_1: ''
    clock_source_2: ''
    clock_source_3: ''
    clock_source_4: ''
    clock_source_5: ''
    clock_source_6: ''
    clock_source_7: ''
    dev_addr: ''
    dev_args: type=x300
    num_mboards: '1'
    time_source_0: ''
    time_source_1: ''
    time_source_2: ''
    time_source_3: ''
    time_source_4: ''
    time_source_5: ''
    time_source_6: ''
    time_source_7: ''
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    label: Sampling Rate (Hz)
    type: real
    value: 10e6/2/16
  states: {}
- name: variable_qtgui_range_amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    min_len: '1000'
    orient: Qt.Horizontal
    start: '0'
    step: 1/1000
    stop: '1'
    value: '1'
  states: {}
- name: variable_qtgui_range_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    min_len: '1000'
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/1000
    stop: samp_rate/2
    value: samp_rate/10
  states: {}
- name: variable_qtgui_range_user_reg
  id: variable_qtgui_range
  parameters:
    label: User Reg
    min_len: '1000'
    orient: Qt.Horizontal
    rangeType: int
    start: '-2**15-1'
    step: '1'
    stop: 2**15-1
    value: '1'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '1'
    min: '-1'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {state: disabled}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '1'
    min: '-1'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: ettus_rfnoc_duc_0
  id: ettus_rfnoc_duc
  parameters:
    block_args: ''
    device_select: '-1'
    freq: '0'
    input_rate: samp_rate*16*4
    instance_index: '-1'
    num_chans: '1'
  states: {}
- name: ettus_rfnoc_rx_streamer_0
  id: ettus_rfnoc_rx_streamer
  parameters:
    args: ''
    num_chans: '1'
    otw: sc16
    output_type: fc32
    vlen: '1'
  states: {state: disabled}
- name: ettus_rfnoc_tx_radio_0
  id: ettus_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: '0'
    block_args: ''
    device_select: '-1'
    frequency: 1.2e9
    gain: '70'
    instance_index: '-1'
    num_chans: '1'
    rate: samp_rate
  states: {}
- name: ettus_rfnoc_tx_streamer_0
  id: ettus_rfnoc_tx_streamer
  parameters:
    args: ''
    input_type: fc32
    num_chans: '1'
    otw: sc16
    vlen: '1'
  states: {}
- name: qpsk_PulseShapingFilter_0
  id: qpsk_PulseShapingFilter
  parameters:
    block_args: ''
    device_select: '-1'
    instance_select: '-1'
    user_reg: '0'
  states: {}
- name: qpsk_conv32Bto2B_0
  id: qpsk_conv32Bto2B
  parameters:
    block_args: ''
    device_select: '-1'
    instance_select: '-1'
    user_reg: '0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', ettus_rfnoc_tx_streamer_0, '0']
- [analog_random_source_x_0, '0', blocks_int_to_float_0, '0']
- [analog_random_source_x_0_0, '0', blocks_int_to_float_0_0, '0']
- [blocks_float_to_complex_0, '0', ettus_rfnoc_tx_streamer_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_int_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_int_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [ettus_rfnoc_duc_0, '0', ettus_rfnoc_tx_radio_0, '0']
- [ettus_rfnoc_rx_streamer_0, '0', qtgui_const_sink_x_0, '0']
- [ettus_rfnoc_tx_streamer_0, '0', qpsk_conv32Bto2B_0, '0']
- [qpsk_PulseShapingFilter_0, '0', ettus_rfnoc_duc_0, '0']
- [qpsk_conv32Bto2B_0, '0', ettus_rfnoc_rx_streamer_0, '0']
- [qpsk_conv32Bto2B_0, '0', qpsk_PulseShapingFilter_0, '0']

metadata:
  file_format: 1
